# Keil uVision project GPIO.uvproj, settings and files
target GPIO (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: GPIO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F4XX
  c include: ..\;..\..\Libraries\CMSIS\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_LCD_Driver\inc;..\..\Libraries\UART\inc;..\..\Libraries\SysTick\inc;..\..\Libraries\Encoder\inc;..\..\Libraries\PWM\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK_ARM
    ../../Libraries/CMSIS/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32F4_StdPeriph
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../: main.c system_stm32f4xx.c
  group UserLIB
    ../../Libraries/STM32_LCD_Driver/src/: lcd.c reprintf.c
    ../../Libraries/UART/src/: UART.c
    ../../Libraries/SysTick/src/: SysTick.c
    ../../Libraries/Encoder/src/: Encoder.c
    ../../Libraries/PWM/src/: PWM.c
